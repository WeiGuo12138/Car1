# Keil uVision project GX_Logistics_MC.uvprojx, settings and files
target GX_Logistics_MC (ARM-ADS)
  device: STM32F105R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x800FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: GX_Logistics_MC +hex
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F105xC
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Code\Bsp;..\Code\Device;..\Code\Module;..\Code\Ctrlsys;..\Code\HARDWARE\core;..\Code\HARDWARE\platform
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f105xc.s
  group Application/User
    ../Src/: main.c stm32f1xx_it.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
    ../Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group Ctrlsys
    ../Src/: stm32f1xx_hal_msp.c
    ../Code/Ctrlsys/: filter.c pcma13.c pid.c ctrlsys.h filter.h pcma13.h pid.h
  group Bsp
    ../Code/Bsp/: bsp_gpio.c bsp_gpio.h bsp_can.c bsp_can.h delay.c iic.c tim.c adc.c usart.c adc.h
    ../Src/: spi.c
  group Device
    ../Code/Device/: device_led.c device_led.h device_m2006.c device_m2006.h oled.c oled.h oledfont.h protocal.c protocal.h
  group Module
    ../Code/Module/: module_chassis.c module_chassis.h
